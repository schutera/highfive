#include "telemetry.h"

#include <cstdio>
#include <string>

namespace hf {

namespace {

// JSON-escape a single string value, including surrounding quotes.
// Per RFC 8259: ", \, control chars (U+0000..U+001F) need escaping.
// Embedded nulls are emitted as  — the firmware ring buffer can
// hold them so they must round-trip through the wire format.
void appendEscapedString(std::string& out, const std::string& s) {
    out.push_back('"');
    for (unsigned char c : s) {
        switch (c) {
            case '"':  out += "\\\""; break;
            case '\\': out += "\\\\"; break;
            case '\b': out += "\\b";  break;
            case '\f': out += "\\f";  break;
            case '\n': out += "\\n";  break;
            case '\r': out += "\\r";  break;
            case '\t': out += "\\t";  break;
            default:
                if (c < 0x20) {
                    char esc[8];
                    std::snprintf(esc, sizeof(esc), "\\u%04x", c);
                    out += esc;
                } else {
                    out.push_back(static_cast<char>(c));
                }
        }
    }
    out.push_back('"');
}

void appendStringField(std::string& out, const char* name,
                       const std::string& value) {
    out.push_back('"');
    out += name;
    out += "\":";
    appendEscapedString(out, value);
    out.push_back(',');
}

template <typename T>
void appendNumberField(std::string& out, const char* name, T value) {
    out.push_back('"');
    out += name;
    out += "\":";
    out += std::to_string(value);
    out.push_back(',');
}

}  // namespace

std::string buildTelemetryJson(const TelemetryInputs& inputs) {
    std::string out;
    // Pre-reserve: log is the largest variable-size field (~2 KB on device);
    // 256 bytes covers all the fixed-shape scalars and field names.
    out.reserve(inputs.log.size() + 256);

    out.push_back('{');
    appendStringField(out, "fw", inputs.fw);
    appendNumberField(out, "uptime_s", inputs.uptime_seconds);
    appendStringField(out, "last_reset_reason", inputs.last_reset_reason);
    // Optional field: only emit when the breadcrumb actually carried a
    // stage forward across the previous reboot. Keeps the existing
    // schema byte-for-byte intact on clean boots so .log.json sidecars
    // produced before this field existed remain a valid subset.
    if (!inputs.last_stage_before_reboot.empty()) {
        appendStringField(out, "last_stage_before_reboot",
                          inputs.last_stage_before_reboot);
    }
    appendNumberField(out, "free_heap", inputs.free_heap);
    appendNumberField(out, "min_free_heap", inputs.min_free_heap);
    appendNumberField(out, "rssi", inputs.rssi);
    appendNumberField(out, "wifi_reconnects", inputs.wifi_reconnects);

    out += "\"last_http_codes\":[";
    for (std::size_t i = 0; i < inputs.last_http_codes.size(); ++i) {
        if (i > 0) out.push_back(',');
        out += std::to_string(inputs.last_http_codes[i]);
    }
    out += "],";

    // log is the final field — no trailing comma
    out += "\"log\":";
    appendEscapedString(out, inputs.log);

    out.push_back('}');
    return out;
}

}  // namespace hf
